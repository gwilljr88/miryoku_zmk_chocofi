## config/boards/shields/custom_view_adapter/Kconfig.shield
```kconfig
config SHIELD_CUSTOM_VIEW_ADAPTER
    def_bool $(shields_list_contains,custom_view_adapter)
```
